# IAR project final-project-240lx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Owner\Desktop\Desktop Files\stanford\junior year\quarter 3\CS 240LX\final-project-240lx\drivers; C:\Users\Owner\Desktop\Desktop Files\stanford\junior year\quarter 3\CS 240LX\final-project-240lx\drivers\devices; C:\Users\Owner\Desktop\Desktop Files\stanford\junior year\quarter 3\CS 240LX\final-project-240lx\application; C:\Users\Owner\Desktop\Desktop Files\stanford\junior year\quarter 3\CS 240LX\final-project-240lx\drivers\devices\STSW-IMG009\STSW-IMG009_v3.5.5\API\core; C:\Users\Owner\Desktop\Desktop Files\stanford\junior year\quarter 3\CS 240LX\final-project-240lx\drivers\devices\STSW-IMG009\STSW-IMG009_v3.5.5\API\platform
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: final-project-240lx.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: config.h controller-hardware.c controller-hardware.h hardware.c hardware.h init.c main.c retarget.c start.S
  group application
    application/: drone_constants.h esc.h pid.h
  group drivers
    drivers/: adc.c adc.h exti.c exti.h flash.h i2c.c i2c.h memmap.h nvic.h pin.c pin.h rcc.c rcc.h scb.h spi.c spi.h syscfg.h systick.c systick.h timer.c timer.h usart.c usart.h utils.h
  group drivers/devices
    drivers/devices/: lsm6ds3.c lsm6ds3.h nrf24l01p.c nrf24l01p.h
  group drivers/devices/vl53l1
    drivers/devices/STSW-IMG009/STSW-IMG009_v3.5.5/API/platform/: vl53l1_platform.c vl53l1_platform.h vl53l1_types.h
    drivers/devices/STSW-IMG009/STSW-IMG009_v3.5.5/API/core/: VL53L1X_api.c VL53L1X_api.h VL53L1X_calibration.c VL53L1X_calibration.h
  group Linker
    linker/: stm32f411xx.icf
